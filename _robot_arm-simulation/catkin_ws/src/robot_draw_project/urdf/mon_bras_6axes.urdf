Commit message: ros_moveit_project_update

File: _robot_arm-simulation/catkin_ws/src/robot_draw_project/urdf/mon_bras_6axes.urdf (robot description, URDF)
Before this commit: robot robot_impression_6axes, 7 links, 6 joints
Joints:
- joint joint_4: axis 0 0 1 -> 0 1 0
